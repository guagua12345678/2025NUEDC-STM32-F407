# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\5.06)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\1-library;.\2-start;.\3-main;.\4-ware
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group library
    ./1-library/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group start
    ./2-start/: core_cm4.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h startup_stm32f40_41xxx.s
  group main
    ./3-main/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group basic
    ./4-ware/: Delay.c Delay.h task_ctrl.c task_ctrl.h timer_clock.c timer_clock.h key_beep_led.c key_beep_led.h
  group stepper
    ./4-ware/: stepper.c stepper.h stepper_ctrl.c stepper_ctrl.h stepper_pitch.c stepper_pitch.h stepper_yaw.c stepper_yaw.h
  group imu
    ./4-ware/: ahrs.c ahrs.h icm42688.c icm42688.h
  group lcd
    ./4-ware/: lcd.c lcd.h lcd_font.h lcd_init.c lcd_init.h lcd_pic.h lcd_touch.c lcd_touch.h
  group w25q128
    ./4-ware/: w25q128.c w25q128.h spi_flash.c spi_flash.h
  group laser
    ./4-ware/: laser.c laser.h
  group serial
    ./4-ware/: hc05_serial.c hc05_serial.h k230_serial.c k230_serial.h
  group car
    ./4-ware/: encoder.c encoder.h motor.c motor.h pid_location.c pid_location.h pid_speed.c pid_speed.h tracing.c tracing.h
